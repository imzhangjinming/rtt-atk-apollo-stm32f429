# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS
  c misc: --gnu
  c include: applications\OneMessage\src;rt-thread\components\drivers\include;applications;rt-thread\components\drivers\include;libraries\HAL_Drivers\CMSIS\Include;rt-thread\components\drivers\include;rt-thread\components\utilities\ulog;rt-thread\components\drivers\include;board\ports;applications\nand;.;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;applications\OneMessage;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;applications\OneMessage\config;board;rt-thread\include;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;applications\OneMessage\src\comp;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;applications\hello;libraries\HAL_Drivers\drv_flash;libraries\HAL_Drivers\config;rt-thread\components\libc\compilers\common\include;rt-thread\libcpu\arm\common;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;packages\mpu6xxx-latest\inc;applications\OneMessage\src\app;applications\OneMessage\src\core;board\CubeMX_Config\Inc;libraries\HAL_Drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: test_om_port.c main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nand.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_rtc.c drv_sdram.c drv_soft_i2c.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Finsh
    rt-thread/components/finsh/: msh_parse.c shell.c msh.c cmd.c
  group hello
    applications/hello/: hello.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_crc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_rng.c stm32f4xx_hal_i2c.c stm32f4xx_hal_uart.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_usart.c stm32f4xx_hal_nand.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group mpu6xxx
    packages/mpu6xxx-latest/src/: mpu6xxx.c
    packages/mpu6xxx-latest/samples/: mpu6xxx_sample.c
  group OneMessage-port
    applications/OneMessage/src/app/: om_afl.c om_com.c om_evt.c om_fmt.c om_log.c om_msg.c
    applications/OneMessage/src/comp/: om_color.c om_crc.c om_fifo.c om_list.c om_rbt.c
    applications/OneMessage/src/core/: om_core.c
    applications/OneMessage/src/: om.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
